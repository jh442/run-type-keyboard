## config/boards/shields/runtype/Kconfig.defconfig
```kconfig
if SHIELD_RUNTYPE
            
config ZMK_KEYBOARD_NAME
    default "runtype"

endif
```
